# Keil uVision project s28a_c07a_line_follower.uvprojx, settings and files
target s28a_c07a_line_follower (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: s28a_c07a_line_follower +hex
  BeforeMake: cmd.exe /C "..\tools\generate_syscfg.bat"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: E:\ti\mspm0_sdk_2_01_00_03\source\third_party\CMSIS\Core\Include,E:\ti\mspm0_sdk_2_01_00_03\source,../app,../board,../communication,../control,../drivers,../generated
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507_flash.sct
  link misc: E:\ti\mspm0_sdk_2_01_00_03\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group App
    ../app/: app_main.c competition_mode.c line_follow_task.c balance_controller.c button_input.c
  group Communication
    ../communication/: bluetooth_service.c
  group Control
    ../control/: vehicle_controller.c
  group Drivers
    ../drivers/: line_sensor.c encoder_driver.c motor_driver.c oled_driver.c bluetooth_uart.c debug_uart.c
  group Config
    ../config/: board.syscfg
  group Generated
    ../generated/: ti_msp_dl_config.h ti_msp_dl_config.c Event.dot
  group Startup
    ./: startup_mspm0g350x_uvision.s
