<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/s28a_c07a_line_follower_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>
